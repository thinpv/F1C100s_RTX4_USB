# Keil uVision project spl-separated.uvproj, settings and files
target Product (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: spl-separated
  AfterMake: fromelf --bincombined --output="$P..\output\@L.bin" !L
  AfterMake: $P..\output\postscript.bat @L.bin
  c flags: Optim=4 oTime=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: PCB_TINY200V1
  c include: .\users\include;.\machine\include;.\periph\include;.\include;.\emwin\Include
  asm define: PCB_TINY200V1
  scatter file: .\system\ldscript.sct
  link misc: --datacompressor=on
  group Machine
    ./machine/: f1c100s-intc.c sys-uart.c
  group System
    ./system/: startup_F1C100s.s spl.s uboot.s mmu_a.s mmu_c.c ubox_a.s Retarget.c target_F1C100s.c RTX_Conf_F1C100s.c efx_main.c
  group Peripheral
    ./periph/: clk-f1c100s-pll.c fb-f1c100s.c gpio-f1c100s.c pwm-f1c100s.c reset-f1c100s.c
  group Users Code
    ./users/: usrentry.c
