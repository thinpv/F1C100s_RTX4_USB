# Keil uVision project usb_vendor_cdc.uvproj, settings and files
target Product (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: spl-separated
  AfterMake: fromelf --bincombined --output="$Poutput\@L.bin" !L
  AfterMake: $Poutput\postscript.bat @L.bin
  c flags: Optim=4 oTime=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: PCB_TINY200V2 CFG_TUSB_MCU=OPT_MCU_F1C100S CFG_TUSB_OS=OPT_OS_RTX4
  c include: .\users\include;.\..\machine\include;.\..\periph\include;.\..\include;.\..\emwin\Include;.\..\tinyusb\src;.\..\tinyusb\hw
  asm define: PCB_TINY200V2
  scatter file: .\..\system\ldscript.sct
  link misc: --datacompressor=on
  group Machine
    ./../machine/: f1c100s-intc.c sys-uart.c
  group System
    ./../system/: startup_F1C100s.s spl.s uboot.s mmu_a.s mmu_c.c Retarget.c ubox_a.s target_F1C100s.c RTX_Conf_F1C100s.c efx_main.c
  group Peripheral
    ./../periph/: clk-f1c100s-pll.c fb-f1c100s.c gpio-f1c100s.c pwm-f1c100s.c reset-f1c100s.c
  group Users Code
    ./users/: usrentry.c usb_descriptors.c
  group TinyUSB
    ./../tinyusb/src/: tusb.c
    ./../tinyusb/src/device/: usbd_control.c usbd.c
    ./../tinyusb/src/common/: tusb_fifo.c
    ./../tinyusb/src/class/hid/: hid_device.c
    ./../tinyusb/src/portable/sunxi/: dcd_sunxi_musb.c
    ../tinyusb/src/class/cdc/: cdc_device.c
    ../tinyusb/src/class/vendor/: vendor_device.c
